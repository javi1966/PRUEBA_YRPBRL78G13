# IAR project ddddd.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cgc.c r_cgc_user.c r_serial.c r_serial_user.c r_adc.c r_adc_user.c r_wdt.c r_wdt_user.c
