# IAR project ssssss.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F1006A RL78 - R5F1006A
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: user_include\
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group applilet_src
    applilet3_src/: CG_main.c CG_systeminit.c CG_system.c CG_system_user.c CG_timer.c CG_timer_user.c CG_wdt.c CG_wdt_user.c
