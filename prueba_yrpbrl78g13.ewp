# IAR project prueba_yrpbrl78g13.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 512
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: AD_AN13.c AD_AN13.h BT_JY104.c BT_JY104.h delay.c delay.h intrinsics.h ior5f100le.h ior5f100le_ext.h lcd.c lcd.h main.c MCP6S92.c MCP6S92.h RTC.c RTC.h
